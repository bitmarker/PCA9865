<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>chip_11cxx_lib</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>csp</name>
    <file>
      <name>$PROJ_DIR$\acmp_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\adc_1125.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\adc_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\chip_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\clock_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\dac_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpio_11xx_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpio_11xx_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\gpiogroup_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\i2c_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\iocon_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\pinint_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\pmu_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\chip_common\ring_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ssp_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sysctl_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sysinit_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timer_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart_11xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\wwdt_11xx.c</name>
    </file>
  </group>
</project>


