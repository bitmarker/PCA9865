# IAR project PC9685_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: vendor\software\lpc_core\lpc_chip\chip_11xx; vendor\software\lpc_core\lpc_chip\chip_common; vendor\software\lpc_core\lpc_chip; vendor\software\CMSIS\CMSIS\Include; vendor\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: vendor\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    vendor/software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11cxx_lib/Exe/: chip_11cxx_lib.a
    ./: general.h i2c.c i2c.h main.c pca9685.c pca9685.h
    vendor/applications/lpc11xx/startup_code/: iar_startup_lpc11xx.s sysinit.c
